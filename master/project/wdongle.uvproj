# Keil uVision project wdongle.uvproj, settings and files
target Target 1 (MCS-51)
  device: nRFLU1P-F32 Nordic Semiconductor
  cpu: IRAM(0-0xFF) IROM(0-0x7FFF) XRAM (0x8000-0x87FF) CLOCK(16000000) MODC2
  output: wdongle +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51
    ../src/: descriptors.c hal_nrf.c hal_nrf_hw.c hal_uart.c nrf_app.c print.c usb.c main.c t2.c master.c hal_delay.c
